# Keil uVision project BH-F103.uvprojx, settings and files
target IAP_CAN (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IAP_CAN
  BeforeMake: G:\STM32\stm32make\远峰can总线升级固件\CAN总线IAP接收机\Project\RVMDK（uv5）\VerManage.exe
  c flags: Optim=1 uC99=1 uGnu=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Bsp\Applications;..\..\Bsp\Drivers;..\..\Bsp\Libraries\CMSIS;..\..\Bsp\Libraries\FWlib\inc;..\..\Bsp\Libraries\System;..\..\Bsp\Peripheral\usart;..\..\APP\CAN;..\..\APP\IAP;..\..\Bsp\Libraries\System\delay;..\..\Bsp\Libraries\System\sys;..\..\Bsp\Libraries\System\usart;..\..\APP\STMFLASH;..\..\APP;..\..\APP\Key;..\..\Bsp\Drivers\OLED;..\..\APP\Oled;..\..\Bsp\Drivers\i2c;..\..\APP\TIMER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../../APP/CAN/: can.c
    ../../APP/IAP/: iap.c
    ../../APP/STMFLASH/: stmflash.c
    ../../APP/Key/: bsp_key.c
    ../../APP/TIMER/: timer.c
  group Appplication
    ../../Bsp/Applications/: main.c
  group Drivers
    ../../APP/Oled/: OLED12864.c
    ../../Bsp/Drivers/i2c/: bsp_i2c_ee.c bsp_i2c_gpio.c
  group System
    ../../Bsp/Libraries/System/: stm32f10x_it.c
    ../../Bsp/Libraries/System/delay/: delay.c
    ../../Bsp/Libraries/System/sys/: sys.c
    ../../Bsp/Libraries/System/usart/: usart.c
  group Libriries
    ../../Bsp/Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../../Bsp/Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
    ../../Bsp/Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
